# Keil uVision project learning_stand_hw_short_test.uvprojx, settings and files
target learning_stand (6130001::V6.13.1::.\ARMCLANG)
  device: STM32F072RBTx STMicroelectronics
  pack: Keil.STM32F0xx_DFP.2.1.0
  cpu: IRAM(0x20000000,0x00004000) IROM(0x08000000,0x00020000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: learning_stand_hw_test
  c flags: Optim=7 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=3
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x4000
  group src
    ./: main.c hal.h systick.h systick.c
software components: CMSIS:CORE 5.4.0, Device:Startup 1.0.0
