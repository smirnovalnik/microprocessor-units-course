# Keil uVision project learning_stand_hw_test.uvprojx, settings and files
target learning_stand (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F072RBTx STMicroelectronics
  pack: Keil.STM32F0xx_DFP.2.1.0
  cpu: IRAM(0x20000000,0x00004000) IROM(0x08000000,0x00020000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: learning_stand_hw_test
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x4000
  group src
    ./: main.c hal.h
    Z:/Dropbox/Development/microprocessor-units-course/tests/learning_stand_hw_test/: mt20s4a.h mt20s4a.c systick.h systick.c
software components: CMSIS:CORE 5.4.0, Compiler:I/O:STDIN 1.2.0, Compiler:I/O:STDOUT 1.2.0, Device:Startup 1.0.0
